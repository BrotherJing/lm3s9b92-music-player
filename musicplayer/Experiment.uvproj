# Keil uVision project Experiment.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S9B96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Experiment
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B96 TARGET_IS_TEMPEST_RB1
  c include: ..\musicplayer;H:\tempInstall\StellarisWare;H:\tempInstall\StellarisWare\boards\Smart-9B92-C3;H:\tempInstall\StellarisWare\third_party
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\Experiment.sct
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: startup_rvmdk.S main.c UARTConfigure.c UARTISR.c GPIODriverConfigure.c SysCtlConfigure.c TimerConfigure.c
    ./drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c sound.c touch.c tlv320aic23b.c
    H:/tempInstall/StellarisWare/third_party/fatfs/src/: ff.c
    H:/tempInstall/StellarisWare/third_party/fatfs/port/: mmc-dk-lm3s9b96.c
    H:/tempInstall/StellarisWare/utils/: ustdlib.c uartstdio.c
  group Libraries
    H:/tempInstall/StellarisWare/driverlib/rvmdk/: driverlib.lib
    H:/tempInstall/StellarisWare/grlib/rvmdk/: grlib.lib
